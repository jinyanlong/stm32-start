# Keil uVision project PigeonHomeYY.uvproj, settings and files
target HOSTV6_CANV7_2G (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PigeonHomeV6_RFV7_2G +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,PIGEON_V6,GSM_MC55I,CAN_V7,__DEBUG
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\Core\CM3;..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\FreeRTOS9\Source\include;..\FreeRTOS9\Source\portable\RVDS\ARM_CM3;.\Source;.\Source\CommFunc;.\Source\Config;.\Source\Form;.\Source\HAL_Driver;.\Source\HAL_PORT;.\Source\LFTAG;.\Source\SAM;.\Source\Share;.\Source\USB;.\SOURCE\CANReader;.\SOURCE\Draw;.\SOURCE\FILESYS;.\SOURCE\GPRS;.\SOURCE\GPS;.\SOURCE\Keyboard;.\SOURCE\Timer;.\SOURCE\Voice
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group FreeRTOS_Core
    ../FreeRTOS9/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
  group FreeRTOS_Include
    ./../FreeRTOS9/Source/include/: croutine.h
    ../FreeRTOS9/Source/include/: deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h
  group FreeRTOS_Portable
    ../FreeRTOS9/Source/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../FreeRTOS9/Source/portable/MemMang/: heap_1.c
  group Lib-CMSIS
    ../Libraries/CMSIS/Core/CM3/: core_cm3.c core_cm3.h
    ../Libraries/CMSIS/Device/ST/STM32F10x/Include/: stm32f10x.h system_stm32f10x.h
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group Lib-STM32F10x
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Src-Config
    ./: stringRes2.txt
    ./Source/Config/: app_cfg.h includes.h stm32f10x_conf.h
    ./SOURCE/Config/: FreeRTOSConfig.h STM32F10x_os.s
  group Src-Share
    ./Source/Share/: SFLib.C DesBox.c DesCrypt.c desbox.h DesCrypt.h SFLib.h SFTypes.h
    ./SOURCE/Share/: Exception.h Exception.c mem_alloc.h mem_alloc.c ByteStream.h
  group Src-Main
    ./Source/: AppMain.c
    ./SOURCE/: MessageLoop.c MessageLoop.h FileFunc.c FileFunc.h tagList.c tagList.h RaceTask.c RaceTask.h RaceData.c RaceData.h RaceFunc.c RaceFunc.h SMD.c SMD.h tagCache.c tagCache.h
  group Src-Hal
    ./Source/HAL_Driver/: halCPU.c halCPU.h
    ./SOURCE/HAL_Driver/: halUart.h halUart.c
  group Src-LFTAG
    ./Source/LFTAG/: TTF.C halLF.c HiTagS.C TTF.h EM4205.h halLF.h Hitags.h
    ./SOURCE/LFTAG/: HtCrypto.c HtCrypto.h Id64.c Id64.h ISO11784.c ISO11784.h LFReader.c LFReader.h RC110.c RC110.h TagType.h TagType.c FDXM.c FDXM.h
  group Src-File
    ./SOURCE/FILESYS/: halAt45DB.c halAt45DB.h SFile.h SFile.c DataFile.h DataFile.c cache.h cache.c cacheFile.c cacheFile.h
  group Src-Timer
    ./SOURCE/Timer/: RealTimer.c RealTimer.h halDS1302.h halDS1302.c halRTC.c halRTC.h halDS3231.c halDS3231.h
  group Src-Draw
    ./SOURCE/Draw/: CDC.c CDC.h font.c font.h halLCD.h halLCD.c stringRes.h Form.c Form.h MenuForm.c MenuForm.h LCD.h LCD.c
  group Src-Voice
    ./SOURCE/Voice/: halBeep.h Beep.c Beep.h halBeep.c Voice.h Voice.c
  group Src-CommFunc
    ./Source/CommFunc/: Func_Pigeon.c FuncList.c Func_Pigeon.h Func_Common.h Func_LF.h Func_Common.c Func_LF.c
    ./SOURCE/CommFunc/: CommDriver.c CommDriver.h
  group Src-Form
    ./Source/Form/: ConnectForm.c MainForm.c MonitorForm.c RecordForm.c
    ./SOURCE/Form/: RaceMgrForm.c RDListForm.c RaceInfoForm.c UnbackForm.c HostInfoForm.c PrintForm.c TrainStartForm.c PhoneEditForm.c DeviceTestForm.c DeviceInfoForm.c LogForm.c TestGPRSForm.c TestGPSForm.c TestLCDForm.c TestSMSForm.c TestTag.c Sysinfo.c TestFlashForm.c UidUnscanForm.c UploadForm.c
  group Src-KeyBoard
    ./SOURCE/Keyboard/: Keyboard.h halKeyboard.c halKeyboard.h Keyboard.c
  group Src-CAN
    ./SOURCE/CANReader/: halCAN.c halCAN.h CANReader.c CANReader.h CAN.c CAN.h
  group Src-GPRS
    ./SOURCE/GPRS/: GPRS.c GPRS.h halGPRS.h halGPRS.c http.h http.c
  group Src-GPS
    ./SOURCE/GPS/: GPS.c GPS.h
  group Src-Led
    ./SOURCE/Led/: halLed.c Led.c
  group Src-2.4G
    ./SOURCE/2.4G/: hal2.4G.c
target HOSTV6_CANV6_3G (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: as above
  output: PigeonHomeV6_CANV6_3G +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,GSM_EHS5E,PIGEON_V6, CAN_V6
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target HOSTV6_CANV7_3G (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: as above
  output: PigeonHomeV6_CANV7_3G +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,GSM_EHS5E,PIGEON_V6, CAN_V7
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target HOSTV7_CANV7_EC20 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: as above
  output: PigeonHomeV7_CANV7_EC20 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,PIGEON_V7,CAN_V7,GSM_EC20_MINIPCI
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target HOSTV7_CANV7_UBLOX (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: as above
  output: PigeonHomeV7_UBLOX_4G +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,PIGEON_V7,CAN_V7,GSM_UBLOX_4G,__DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target HOSTV7_CANV6_EC20 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: as above
  output: PigeonHomeV7_CANV6_EC20 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,PIGEON_V7,CAN_V6,GSM_EC20_MINIPCI
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target HOSTV7_CANV6_UBLOX (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: as above
  output: PigeonHomeV7_UBLOX_4G +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,PIGEON_V7,CAN_V6,GSM_UBLOX_4G,__DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target DEBUG (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: as above
  output: PigeonHomeV7_DEBUG +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,PIGEON_V7,CAN_V7,GSM_EC20_MINIPCI,__DEBUG
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\Core\CM3;..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\FreeRTOS9\Source\include;..\FreeRTOS9\Source\portable\RVDS\ARM_CM3;.\Source;.\Source\CommFunc;.\Source\Config;.\Source\Form;.\Source\HAL_Driver;.\Source\HAL_PORT;.\Source\LFTAG;.\Source\SAM;.\Source\Share;.\Source\USB;.\SOURCE\CANReader;.\SOURCE\Draw;.\SOURCE\FILESYS;.\SOURCE\GPRS;.\SOURCE\GPS;.\SOURCE\Keyboard;.\SOURCE\Timer;.\SOURCE\Voice;.\SOURCE\Led;.\SOURCE\2.4G
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
