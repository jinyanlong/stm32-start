# Keil uVision project SchoolActivation.uvproj, settings and files
target DEBUG (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DEBUG +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,__LF_CRC16,__DEBUG
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\Core\CM3;..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\FreeRTOS9\Source\include;..\FreeRTOS9\Source\portable\RVDS\ARM_CM3;.\Source;.\Source\CommFunc;.\Source\Config;.\Source\Form;.\Source\HAL_Driver;.\Source\HAL_PORT;.\Source\LFTAG;.\Source\SAM;.\Source\Share;.\Source\USB;.\SOURCE\CANReader;.\SOURCE\Draw;.\SOURCE\FILESYS;.\SOURCE\GPRS;.\SOURCE\GPS;.\SOURCE\Keyboard;.\SOURCE\Timer;.\SOURCE\Main;.\SOURCE\Led;.\SOURCE\Nrf;.\SOURCE\Lf;.\SOURCE\GUI;.\SOURCE\Flash;.\SOURCE\Comm;.\SOURCE\PcComm;.\SOURCE\Beep
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group FreeRTOS_Core
    ../FreeRTOS9/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
  group FreeRTOS_Include
    ./../FreeRTOS9/Source/include/: croutine.h
    ../FreeRTOS9/Source/include/: deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h
  group FreeRTOS_Portable
    ../FreeRTOS9/Source/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../FreeRTOS9/Source/portable/MemMang/: heap_1.c
  group Lib-CMSIS
    ../Libraries/CMSIS/Core/CM3/: core_cm3.c core_cm3.h
    ../Libraries/CMSIS/Device/ST/STM32F10x/Include/: stm32f10x.h system_stm32f10x.h
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group Lib-STM32F10x
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Src-Config
    ./Source/Config/: app_cfg.h includes.h stm32f10x_conf.h
    ./SOURCE/Config/: FreeRTOSConfig.h STM32F10x_os.s
  group Src-Share
    ./SOURCE/Share/: DesBox.c DesCrypt.c md5.c SFLib.C ByteStream.h DesBox.h DesCrypt.h md5.h SFLib.h SFTypes.h mem_alloc.c mem_alloc.h
  group Src-Main
    ./SOURCE/Main/: AppMain.c MainTask.c MainData.c
  group Src-Hal_Driver
    ./Source/HAL_Driver/: halCPU.c halCPU.h
    ./SOURCE/HAL_Driver/: halUart.c halUart.h
  group Src-Timer
    ./SOURCE/Timer/: RealTimer.c RealTimer.h halRTC.c halRTC.h
  group Src-Led
    ./SOURCE/Led/: halLED.c Led.c
target REALEASE (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: as above
  output: DEBUG +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,__LF_CRC16,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
